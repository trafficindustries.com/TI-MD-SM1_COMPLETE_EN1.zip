Properties of the parts of a building model (IFC4)

# File
Description: Traffic Industries product reference geometry and properties; local coordinates
File name: model.ifc
Time: 2026-09-20T21:29:47Z
Author: MIR GROUP
Organization: MIR GROUP
Written by: IfcOpenShell 0.8.4
Made in: Traffic Industries EN1

# IfcProject, Traffic Industries / MIR GROUP product library
LongName: Manual post driver - sheet metal assembly

# IfcBuilding, Local product coordinate container
Description: Generic model container; not an actual building or geographic location

# IfcBuildingElementPart: ELASTOMER_GRIP (2)
In: Local product coordinate container
Description: Traffic Industries / MIR GROUP; Elastomer; PredefinedType: USERDEFINED; Material: Elastomer
Name
Right elastomer grip | Pset_TI_Component_grip_right - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: grip_right; ComponentMaterial: Elastomer; Role: ELASTOMER_GRIP; LengthUnit: mm
Left elastomer grip | Pset_TI_Component_grip_left - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: grip_left; ComponentMaterial: Elastomer; Role: ELASTOMER_GRIP; LengthUnit: mm

# IfcBuildingElementPart: ROLLED_SHEET_TUBE (2)
In: Local product coordinate container
Description: Traffic Industries / MIR GROUP; Steel; PredefinedType: USERDEFINED; Material: Steel
Name
Right hollow tube handle | Pset_TI_Component_handle_right - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: handle_right; ComponentMaterial: Steel; Role: ROLLED_SHEET_TUBE; LengthUnit: mm
Left hollow tube handle | Pset_TI_Component_handle_left - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: handle_left; ComponentMaterial: Steel; Role: ROLLED_SHEET_TUBE; LengthUnit: mm

# IfcBuildingElementPart: SHEET_PLATE (7)
In: Local product coordinate container
Description: Traffic Industries / MIR GROUP; Steel; PredefinedType: USERDEFINED; Material: Steel
Name
Front body sheet | Pset_TI_Component_front - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: front; ComponentMaterial: Steel; Role: SHEET_PLATE; LengthUnit: mm
Rear body sheet | Pset_TI_Component_back - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: back; ComponentMaterial: Steel; Role: SHEET_PLATE; LengthUnit: mm
Left closing sheet | Pset_TI_Component_side_left - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: side_left; ComponentMaterial: Steel; Role: SHEET_PLATE; LengthUnit: mm
Right closing sheet | Pset_TI_Component_side_right - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: side_right; ComponentMaterial: Steel; Role: SHEET_PLATE; LengthUnit: mm
Top cap sheet | Pset_TI_Component_head - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: head; ComponentMaterial: Steel; Role: SHEET_PLATE; LengthUnit: mm
Left handle attachment sheet | Pset_TI_Component_strap_left - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: strap_left; ComponentMaterial: Steel; Role: SHEET_PLATE; LengthUnit: mm
Right handle attachment sheet | Pset_TI_Component_strap_right - ProductCode: TI-MD-SM1; Brand: Traffic Industries; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; ComponentId: strap_right; ComponentMaterial: Steel; Role: SHEET_PLATE; LengthUnit: mm

# IfcElementAssembly: Roadside delineator installation tools, Manual post driver - sheet metal assembly
In: Local product coordinate container
Description: Traffic Industries product; MIR GROUP; PredefinedType: USERDEFINED; Document: Manual post driver - sheet metal assembly https://trafficindustries.com/en/products/lane-guidance/roadside-delineator-posts/
Pset_TI_Product - Brand: Traffic Industries; BrandWebsite: https://trafficindustries.com/; BrandOwner: MIR GROUP; Supplier: MIR GROUP; CompanyDescription: Engineering Manufacturing Industry and Trade.; CompanyPhone: +90 532 711 2185; CompanyWebsite: https://www.mirgrp.com/; CompanyAddress: Macun Mah.Batı Bulvarı ATB iş Merkezi,No.192; CompanyPostalAddress: P.Code 06105 Yenimahalle-Ankara/Turkiye; PostalCode: 06105; City: Ankara; Country: Turkiye; ProductCode: TI-MD-SM1; ProductName: Manual post driver - sheet metal assembly; ProductGroup: Roadside delineator installation tools; ProductWebsite: https://trafficindustries.com/en/products/lane-guidance/roadside-delineator-posts/; DesignRevision: SM1; DocumentRevision: EN1; DrawingLanguage: English; IssueDate: 2026-09-09; DesignStatus: CAD design accepted by product owner; LengthUnit: mm; CoordinateSystem: Local product coordinates; Z up; body lower end Z=0; no geospatial CRS; OverallWidth_mm: 328; OverallDepth_mm: 36; OverallHeight_mm: 603; BodyWidth_mm: 120; BodyDepth_mm: 20; BodyLength_mm: 600; BodyWall_mm: 2; ClearBoreWidth_mm: 116; ClearBoreDepth_mm: 16; CapWidth_mm: 124; CapDepth_mm: 24; CapThickness_mm: 3; AttachmentSheetLength_mm: 300; AttachmentSheetWidth_mm: 24; AttachmentSheetThickness_mm: 2; HandleOutsideDiameter_mm: 20; HandleInsideDiameter_mm: 16; HandleWall_mm: 2; HandleCentrelineRadius_mm: 40; HandleCentrelineLengthRef_mm: 373.664; HandleRootX_mm: -62 / +62; HandleRootZ_mm: 340 / 580; GripOutsideDiameter_mm: 36; GripInsideDiameter_mm: 20; GripLength_mm: 140; GripEndRadius_mm: 2; GripZ_mm: 390 to 530; HandClearance_mm: 66; NumberOfParts: 11; NumberOfFlatSheets: 7; Material: Weldable steel sheet and welded hollow steel tube; nonstructural elastomer grips; SteelGrade: Not specified; MeasuredWeight_kg: Not measured; WeldProposal: Continuous external joints; nominal fillet leg z2 mm; keep bore free of weld protrusions; ProposedCutTolerance_mm: +/-0.5; MinimumAssembledBore_mm: 115 x 15; MatchedPostSection_mm: 100 x 10; MatchedPostWall_mm: 3; PhysicalImpactTest: Not performed; WeldQualification: Not performed; SurfaceFinish: Not specified; SourceGeometrySHA256: edc2197d57714028546ac9ae09ca8bda57157103f469bfa5437d0ccd79adf7d8
